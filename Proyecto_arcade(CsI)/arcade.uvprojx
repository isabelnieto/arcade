# Keil uVision project arcade.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.5.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: controlador_ambiente
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./: main.c signals.h
  group lcd
    ./: Arial12x12.h LCD.c LCD.h
  group joystick
    ./: Rebotes.c rebotes.h
  group RGB
    ./: led_rgb.c led_rgb.h
  group Arcade
    ./: Arcade.c Arcade.h
  group Puntos
    ./: puntos.c puntos.h
  group Nuevo Perfil
    ./: nuevo_perfil.c nuevo_perfil.h
  group Minijuegos
    ./: minijuegos.c minijuegos.h
  group Memoria
    ./: IAP.c IAP.h lpc_types.h lpc17xx_iap.c lpc17xx_iap.h
  group Ping-pong
    ./: numbers.h PingPong.c PingPong.h Timer_pelota.c
  group Potenciometro
    ./: Potenciomentro.c Potenciometro.h
  group Snake
    ./: Snake.c Snake.h SnakeTimer.c
  group Zumbador
    ./: Zumbador.c Zumbador.h
software components: CMSIS:CORE 5.2.0, CMSIS:RTOS:Keil RTX 4.81.1, CMSIS Driver:I2C 2.5.0, CMSIS Driver:SPI:SSP 2.7.0, CMSIS Driver:USART 2.6.0, Device:GPDMA 1.2.0, Device:GPIO 1.1.0, Device:PIN 1.0.0, Device:Startup 1.0.0
